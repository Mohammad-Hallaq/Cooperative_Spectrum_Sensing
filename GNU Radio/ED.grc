options:
  parameters:
    author: Mohammad Hallaq
    description: Performance of Energy Detection
    generate_options: qt_gui
    id: ED
    output_language: python
    title: ENERGY_DETECTION
  states: {}

blocks:
- name: Samples_Numb
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 92e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: Samples_Numb
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1.0573'
    init: '0'
    low: '1.0573'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf='0'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '5'
    ymin: '-5'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
