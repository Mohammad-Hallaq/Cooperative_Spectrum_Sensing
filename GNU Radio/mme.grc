options:
  parameters:
    author: Mohammd Hallaq
    description: Perfomance of MME Method
    generate_options: qt_gui
    id: MME
    output_language: python
    title: MME Detection
  states: {}

blocks:
- name: Samples_Number
  id: variable
  parameters:
    value: '4500'
  states: {}
- name: Smoothing_Factor
  id: variable
  parameters:
    value: '32'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 450e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: bloc3_0
  id: epy_block
  parameters:
    L: Smoothing_Factor
    N: Samples_Number
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport math\nfrom numpy import linalg as LA\nimport scipy as sp\nfrom scipy import linalg as sLA\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, N = 1000, L=8, inp = [0]):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='MME Block',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.float32]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.N = N\n        self.L = L\n        self.inp = inp\n        \n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        while len(self.inp) < self.N and all(input_items[0]) != 0:\n            self.inp.extend(input_items[0])\n            output_items[0][:] = 0\n            return len(output_items[0])\n            \n        f = open(\"F:\\FIFTH YEAR\\PROJECT\\GNU Radio\\myfile.txt\", \"a\")\n        f.write(str(len(self.inp))+'\\n')\n        f.close()\n        \n        if len(self.inp) >= self.N:\n           \n            YY = self.inp[0:self.N]\n            Y = np.pad(YY, (0,self.L), 'constant')\n            Y_mid = Y.reshape(self.L+self.N,1)\n            \n            Y2 = Y_mid[:,0]\n            auto = np.correlate(Y2, Y2, mode='full')\n            auto = auto[auto.size//2:]/self.N\n            R = sLA.toeplitz(auto[0:self.L])\n            w,v = LA.eig(R)\n            Test = max(w)/min(w)            \n  \n            output_items[0][:] = Test.real\n            f = open(\"F:\\FIFTH YEAR\\PROJECT\\GNU Radio\\myfile.txt\", \"a\")\n            f.write(str(self.N)+'  '+str(Test)+ '\\n')\n            f.close()\n            \n            self.inp = []\n       \n            return len(output_items[0])\n        \n        #else:\n        #    self.inp.extend(input_items[0])\n        #    output_items[0][:] = 0\n        #    return len(output_items[0])\n        else:\n            output_items[0][:] = 0\n            return len(output_items[0])\n        \n        \n"
    inp: '[]'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1.4451'
    init: '0'
    low: '1.4451'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=2
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}

connections:
- [bloc3_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', bloc3_0, '0']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
